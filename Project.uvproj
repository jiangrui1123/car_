# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Buzzer_LED.c Buzzer_LED.h motor.c motor.h OLED.c OLED.h OLED_Font.c OLED_Font.h Timer0.c Timer0.h UART.c UART.h tracking.c tracking.h
